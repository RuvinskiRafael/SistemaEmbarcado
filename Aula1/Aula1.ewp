# IAR project Aula1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: C:\Users\Rafael\Documents\GitHub\EK-TM4C1294_IAR8\TivaWare_C_Series-2.1.4.178; C:\ti\TivaWare_C_Series-2.1.4.178
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: C:\Users\Rafael\Documents\GitHub\EK-TM4C1294_IAR8\TivaWare_C_Series-2.1.4.178; C:\Users\Rafael\Documents\GitHub\EK-TM4C1294_IAR8; C:\ti\TivaWare_C_Series-2.1.4.178
  OBJCOPY.OOCOutputFile: Aula1.srec
  ILINK.IlinkOutputFile: Aula1.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\TexasInstruments\TM4C1294NC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../TivaWare_C_Series-2.1.4.178/driverlib/ewarm/Exe/: driverlib.a
    ../../../../Aula1/Aula1/src/: main.c
    src/: startup_TM4C1294.s system_TM4C1294_TW.c
